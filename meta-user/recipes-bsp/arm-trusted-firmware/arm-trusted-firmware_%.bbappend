atf_bl33_load = "0x8000000"
EXTRA_OEMAKE_append = " PRELOADED_BL33_BASE=${atf_bl33_load}"
ATF_CONSOLE_zynqmp = "cadence1"
