FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

HDF_BASE = "file://"
HDF_PATH = "ULTRA96V2.xsa"
